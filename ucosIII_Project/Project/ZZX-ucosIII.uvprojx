# Keil uVision project ZZX-ucosIII.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: ZZX-ucosIII
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\User\uC-CPU;..\User\uC-LIB;..\User\uCOS-III\Ports;..\User\uCOS-III\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: app.c
  group uC/OS-III Source
    ../User/uCOS-III/Source/: os_task.c os_var.c os_core.c os_time.c os.h os_cfg.h os_type.h os_cfg_app.c os_cfg_app.h os_prio.c
  group uC/OS-III Ports
    ../User/uCOS-III/Ports/: os_cpu_a.s os_cpu_c.c os_cpu.h
  group uC/CPU
    ../User/uC-CPU/: cpu.h cpu_a.asm cpu_cfg.h cpu_core.c cpu_core.h
  group uC/LIB
    ../User/uC-LIB/: lib_def.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
